inherit externalsrc
S = "/home/sam/projects/ds/containers/controller"

